SRCREV = "5502a2d605f5b6ddf73bf82e79b0651ec5e0a731"

require libiio.inc
